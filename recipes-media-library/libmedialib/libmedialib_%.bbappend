FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0004-single-camera-3a-config-as-sensor-0.patch"
