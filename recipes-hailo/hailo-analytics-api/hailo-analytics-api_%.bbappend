# Hailo's production set: the library, the native application and the face landmarks application with the shared
# models (YOLOv8). The demo applications (CLIP, license plate, privacy mask, case studies, web server, VLM monitor)
# and their models are left out of the image.
PACKAGECONFIG = "face-landmarks native"
