IMAGE_INSTALL:append = " swupdate-public-key"
