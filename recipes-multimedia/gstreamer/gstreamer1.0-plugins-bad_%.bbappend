# SVG overlay: pulls librsvg and its dependencies, and nothing in the image uses it.
PACKAGECONFIG:remove = "rsvg"
