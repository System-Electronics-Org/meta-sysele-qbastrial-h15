# libpsl takes ICU (28 MiB of data) for internationalised domain names; libidn2 does the same.
PACKAGECONFIG = "idn2"
